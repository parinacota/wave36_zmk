## boards/shields/wave36/Kconfig.defconfig
```kconfig
# Central Side Configuration

if SHIELD_MY_BOARD
config SHIELD_WAVE36
    default "wave36"
endif
```
